
# See also https://git.yoctoproject.org/poky/commit/meta/recipes-core/meta/signing-keys.bb?id=ffc3051d09ce85c626301addef9704610ef2b24f
RDEPENDS:${PN}-dev = ""
